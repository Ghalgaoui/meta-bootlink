SRC_URI += "file://001-modified-welcome-message.patch;subdir=nano-4.4"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

