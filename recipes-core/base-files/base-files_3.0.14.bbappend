FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://001-prefer-nano-to-vi-in-profile.patch"
