SRC_URI += "file://inetrf"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

