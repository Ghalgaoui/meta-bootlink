SRC_URI += "file://fragment.cfg;subdir=busybox-1.31.0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

