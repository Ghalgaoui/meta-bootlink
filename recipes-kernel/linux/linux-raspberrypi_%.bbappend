SRC_URI += "file://fragment.cfg;subdir=git"
SRC_URI += "file://bluetooth.cfg;subdir=git"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

